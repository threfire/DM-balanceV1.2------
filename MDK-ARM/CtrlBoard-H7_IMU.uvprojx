# Keil uVision project CtrlBoard-H7_IMU.uvprojx, settings and files
target CtrlBoard-H7_IMU (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00050000) IROM(0x08000000,0x00100000) XRAM(0x30000000,0x00008000) XRAM2(0x38000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: CtrlBoard-H7_IMU +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../User/Algorithm/EKF;../User/Algorithm/kalman;../User/Algorithm/mahony;../User/APP;../User/Bsp;../User/Devices/BMI088;../User/Algorithm/VMC;../User/Controller;../User/Lib;../User/Algorithm/PID;../User/Devices/oled;../User/ROBOT;../User/shoot;../User/chassis;../User/gimbal;../User/message;../User/Devices/USB;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../User/Communication/channel;../User/Communication/core;../User/Communication/example/device;../User/profiler;../User/ui
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x8000
  memory RVCT7: RAM 0x38000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c crc.c dma.c fdcan.c octospi.c rng.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group APP
    ../User/APP/: INS_task.c shoot.c remote_control.c referee.c referee_usart_task.c message_task.c chassis_task.c chassis_power_control.c chassis_behaviour.c gimbal_behaviour.c gimbal_task.c auto_aim.c calibrate_task.c detect_task.c oled_task.c robot_param.h robot_param.c observer.c UI.c light_task.c
  group ROBOT
    ../User/ROBOT/: Balance.c Engineer.c Hero.c Infantry_robot.c Sentinel.c
  group chassis
    ../User/chassis/: Balance_chassis.c Mecanum_chassis.c Omni_chassis.c steering_chassis.c
  group gimbal
    ../User/gimbal/: double_yaw_pitch.c yaw_pitch_direct.c yaw_pitch_linkage.c Multi-axis_robotic_arm.c arm_teach.c
  group shoot
    ../User/shoot/: shoot_3508.c shoot_double.c shoot_none.c
  group ui
    ../User/ui/: ui_interface.c ui_g.c
  group common
    ../User/Communication/core/: comm.c uproto.c
    ../User/Communication/example/device/: comm_app.c platform_stm32.c usb_cdc_port.c
    ../User/Communication/channel/camera/: camera_channel.c
    ../User/Communication/channel/gimbal/: gimbal_channel.c
    ../User/Communication/channel/time_sync/: time_sync_channel.c
  group bsp
    ../User/bsp/: bsp_dwt.c
    ../User/Bsp/: can_bsp.c bsp_PWM.c bsp_usart.c bsp_flash.c bsp_buzzer.c bsp_rc.c bsp_usb.c w25q64.c
  group Controller
    ../User/Controller/: controller.c fifo.c CRC8_CRC16.c GRAVITY.c kinematics.c
  group Algorithm
    ../User/Algorithm/mahony/: mahony_filter.c
    ../User/Algorithm/EKF/: QuaternionEKF.c
    ../User/Algorithm/kalman/: kalman_filter.c
    ../User/Lib/: user_lib.c
    ../User/Algorithm/PID/: pid.c
    ../User/Algorithm/VMC/: VMC_calc.c
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_ospi.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Device
    ../User/Devices/BMI088/: BMI088driver.c BMI088Middleware.c
    ../User/Devices/oled/: OLED.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group DSP
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM7lfdp_math.lib
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 5.5.0
